# Scarthgap requires S without a trailing slash.
S = "${UNPACKDIR}/git"
